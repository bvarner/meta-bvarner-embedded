SYSTEMD_PACKAGES += "${PN}"
SYSTEMD_AUTO_ENABLE_${PN} = "enable"